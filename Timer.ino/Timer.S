#define __SFR_OFFSET 0
#include "avr/io.h"
.global start
.global work

start:
SBI DDRB,5
CBI PORTB,5
LDI R16,0X00
STS TCCR1A,R16
LDI R16,0X04
STS TCCR1B,R16
LDI R16,0X0B
STS TCNT1H,R16
LDI R16,0XDC
STS TCNT1L,R16
RET

work:
SBIS TIFR1,0
RJMP work
SBI TIFR1,0
SBIS PINB,5
SBI PORTB,5
SBIC PINB,5
CBI PORTB,5
RET
