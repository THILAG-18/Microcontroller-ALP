#define __SFR_OFFSET 0
#include "avr/io.h"
.global start
.global work
start:
SBI DDRC,0
SBI DDRB,5
CBI PORTB,5
LDI R16,0X60
STS ADMUX,R16
LDI R16,0XE3
STS ADCSRA,R16
RET

work:
LDS R16,ADCSRA
ANDI R16,0X10
BREQ work
LDS R17,ADCH
LDS R16,ADCSRA
ORI R16,0X10
CPI R17,0XFF
BREQ L
CBI PORTB,5
RJMP L1
L:SBI PORTB,5
L1:RET
